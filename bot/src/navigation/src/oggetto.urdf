Commit message: little objects and obstacles race improving

File: bot/src/navigation/src/oggetto.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry collision box size=0.5 0.5 1; visual box size=0.5 0.5 1
